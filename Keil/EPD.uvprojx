# Keil uVision project EPD.uvprojx, settings and files
target nRF51822_xxAB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: EPD +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: BLE_STACK_SUPPORT_REQD NRF51822 NRF_SD_BLE_API_VERSION=2 S130 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c include: ..\src;..\src\EPD;..\components\toolchain;..\components\drivers_nrf\clock;..\components\drivers_nrf\common;..\components\drivers_nrf\delay;..\components\drivers_nrf\hal;..\components\drivers_nrf\spi_master;..\components\drivers_nrf\twi_master;..\components\drivers_ext\segger_rtt;..\components\libraries\fstorage;..\components\libraries\experimental_section_vars;..\components\libraries\log;..\components\libraries\log\src;..\components\libraries\trace;..\components\libraries\timer;..\components\libraries\util;..\components\ble\common;..\components\ble\ble_advertising;..\components\softdevice\common\softdevice_handler;..\components\softdevice\s130\headers;..\components\softdevice\s130\headers\nrf51
  asm define: as above
  asm include: ..\components;..\components\drivers_nrf\common;..\components\libraries\log;..\components\libraries\log\src;..\components\drivers_nrf\hal;..\components\drivers_nrf\delay;..\components\drivers_nrf\nrf_soc_nosd;..\components\drivers_nrf\spi_master;..\components\drivers_nrf\uart;..\components\libraries\util;..\components\toolchain;..\config;..\EPD;..\GUI
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x5000
  memory RVCT9: RAM 0x20001fe8 size 0x2018
  group App
    ../src/: main.c sdk_config.h
  group EPD
    ../src/EPD/: DEV_Config.c EPD_4in2.c EPD_4in2_V2.c EPD_4in2b_V2.c EPD_ble.c
  group nRF_BLE
    ../components/ble/ble_advertising/: ble_advertising.c
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_Drivers
    ../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/spi_master/: nrf_drv_spi.c
  group nRF_Libraries
    ../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c
    ../components/libraries/timer/: app_timer.c
    ../components/libraries/fstorage/: fstorage.c
  group nRF_Log
    ../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../components/drivers_ext/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group Startup
    ../components/toolchain/arm/: arm_startup_nrf51.s
    ../components/toolchain/: system_nrf51.c
target nRF51802_xxAA (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF51802_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: EPD +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: BLE_STACK_SUPPORT_REQD NRF51802 NRF_SD_BLE_API_VERSION=2 S130 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c include: ..\src;..\src\EPD;..\components\toolchain;..\components\drivers_nrf\clock;..\components\drivers_nrf\common;..\components\drivers_nrf\delay;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\hal;..\components\drivers_nrf\spi_master;..\components\drivers_nrf\twi_master;..\components\drivers_ext\segger_rtt;..\components\libraries\fstorage;..\components\libraries\experimental_section_vars;..\components\libraries\log;..\components\libraries\log\src;..\components\libraries\trace;..\components\libraries\timer;..\components\libraries\util;..\components\ble\common;..\components\ble\ble_advertising;..\components\softdevice\common\softdevice_handler;..\components\softdevice\s130\headers;..\components\softdevice\s130\headers\nrf51
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001fe8 size 0x2018
target nRF51822_xxAB_flash_softdevice (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: s130_nrf51_2.0.1_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: as above
  c include: as above
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x5000
  memory RVCT9: RAM 0x20001fe8 size 0x2018
target nRF51802_xxAA_flash_softdevice (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF51802_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: s130_nrf51_2.0.1_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: as above
  c include: as above
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001fe8 size 0x2018
software components: CMSIS:CORE 4.3.0
